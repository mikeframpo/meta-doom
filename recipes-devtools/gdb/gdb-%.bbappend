
EXTRA_OECONF_remove = " --disable-tui"
EXTRA_OECONF += " --enable-tui"
