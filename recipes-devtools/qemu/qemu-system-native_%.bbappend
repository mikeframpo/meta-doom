
PACKAGECONFIG_append = " sdl"

